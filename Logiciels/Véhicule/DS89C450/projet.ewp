# IAR project projet.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: U:\FRÉDÉRIC DION\Projet\ProjetS4_WB_SD\Logiciel\DS450\Version Finale\DS89C450\_Ver810_lnk51ew_DS89C450.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: CLADCMax1236.cpp CLCaptDist.cpp CLCom2.cpp CLControleMoteurs.cpp CLDAC6574.cpp CLEcran.cpp CLI2CBase.cpp CLI2CPort.cpp CLInOutBase.cpp CLIOPCF8574.cpp CLPile.cpp CLRoue.cpp CLSuiveurLigne.cpp CLVehicule.cpp MainVehicule.cpp
